

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO et4351 
  PIN clk 
    ANTENNAPARTIALMETALAREA 35.7296 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 160.783 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.3832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.3396 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.32175 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 142.646 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 646.071 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.00684 LAYER Via4 ;
  END clk
  PIN resetn 
    ANTENNAPARTIALMETALAREA 4.1804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.8118 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.023175 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 209.968 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 949.049 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.01079 LAYER Via3 ;
  END resetn
  PIN ser_tx 
    ANTENNAPARTIALMETALAREA 1.2852 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7834 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5424 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4696 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 26.8552 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 120.877 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 145.004 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 674.7 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.31338 LAYER Via5 ;
  END ser_tx
  PIN ser_rx 
    ANTENNAPARTIALMETALAREA 1.3964 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2838 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.0624 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3096 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 20.7936 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 93.6 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.6216 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 7.326 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via6 ;
    ANTENNAPARTIALMETALAREA 16.6536 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 75.0276 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 500.41 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 2267.03 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 3.75926 LAYER Via7 ;
  END ser_rx
  PIN flash_csb 
    ANTENNAPARTIALMETALAREA 3.6052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2234 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.3192 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9652 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 2.93975 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.2424 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6196 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.30825 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 23.5989 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 139.778 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 10.442 LAYER Via5 ;
  END flash_csb
  PIN flash_clk 
    ANTENNAPARTIALMETALAREA 3.0112 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5504 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNADIFFAREA 3.839 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9528 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3164 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 8.36068 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 56.5718 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.42205 LAYER Via4 ;
  END flash_clk
  PIN flash_io0 
    ANTENNAPARTIALMETALAREA 3.4872 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6924 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.4592 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.124 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.68318 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.5944 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2036 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1494 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.3718 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 160.203 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 12.2294 LAYER Via5 ;
  END flash_io0
  PIN flash_io1 
    ANTENNAPARTIALMETALAREA 3.0444 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6998 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.4248 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4404 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.68318 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.092 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 22.9716 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 69.3592 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 350.624 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 13.8691 LAYER Via5 ;
  END flash_io1
  PIN flash_io2 
    ANTENNAPARTIALMETALAREA 3.3928 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.2676 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.812 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1828 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.68318 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.0904 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4356 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.16245 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 37.425 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 205.235 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 12.3962 LAYER Via5 ;
  END flash_io2
  PIN flash_io3 
    ANTENNAPARTIALMETALAREA 1.2692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7114 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.948 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.7948 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNADIFFAREA 1.68318 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.1136 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 23.04 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 61.5025 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 313.634 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 12.2459 LAYER Via5 ;
  END flash_io3
END et4351

END LIBRARY
